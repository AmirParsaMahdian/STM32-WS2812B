# Keil uVision project stm32-ws2812b.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32-ws2812b
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c main.h WS2812B.c WS2812B.h config.h
  group User Library
    ./: FLASH.c FLASH.h RCC.c RCC.h TIM.c TIM.h DMA.c DMA.h GPIO.c GPIO.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
